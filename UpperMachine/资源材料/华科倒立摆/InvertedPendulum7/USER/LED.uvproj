# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\I2C;..\HARDWARE\ZLG7290;..\HARDWARE\Servo;..\HARDWARE\GPIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c MyTask.c Globals.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Motor/: Motor.c Encoder1.c Control.c Encoder.c
    ../HARDWARE/TimeBase/: TimeBase.c
    ../HARDWARE/TIM1_PWM/: TIM1_PWM.C
    ../HARDWARE/HX711/: hx711.c
    ../HARDWARE/TIM1_CAP/: TIM1_Cap.c
    ../HARDWARE/ZLG7290/: ZLG7290.c
    ../HARDWARE/I2C/: I2C.c
    ../HARDWARE/KEY/: ZLG_Key.c
    ../HARDWARE/GPIO/: GPIO.C
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/DS18B20/: ds18B20.c
    ../HARDWARE/ExtiKey/: ExtiKey.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: app.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
