# Keil uVision project NRF24L01.uvprojx, settings and files
target NRF24L01 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF24L01 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\NRF24L01;..\HARDWARE\TimeBase;..\SYSTEM;..\HARDWARE\MyGlobals;..\HARDWARE\GLOBALS;..\SYSTEM\APP;..\HARDWARE\UltrasonicWave;..\HARDWARE\ENCODER;..\HARDWARE\Motor;..\USMART;..\HARDWARE\init;..\HARDWARE\NIMING;..\HARDWARE\INIT;..\HARDWARE\NIMING;..\HARDWARE\TimeBase;..\SYSTEM\APP;..\HARDWARE\Motor;..\SYSTEM\APP;..\USER;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\USER;..\USMART;..\CORE;..\HARDWARE\LCD;.\MENU;.\MENU;..\HARDWARE\BEEP;..\HARDWARE\BEEP;..\HARDWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c mytask.c
    ../HARDWARE/init/: init.c
    ./MENU/: menu.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/Motor/: Motor.c Control.c
    ../HARDWARE/TimeBase/: TimeBase.c
    ../HARDWARE/GLOBALS/: globals.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/NIMING/: niming.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HARDWARE/LCD/: ili9320.c hz16.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/APP/: app.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
